Commit message: add different things

File: gym_pybullet_drones/assets/box_obstacle_large.urdf (robot description, URDF)
Before this commit: robot box_obstacle, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.2 0.2 2; visual box size=0.2 0.2 2
